# Keil uVision project iqmath_rts_ops_test_LP_MSPM0L2228_nortos_keil.uvprojx, settings and files
target iqmath_rts_ops_test_LP_MSPM0L2228_nortos_keil (6160000::V6.16::ARMCLANG)
  device: MSPM0L2228 Texas Instruments
  output: iqmath_rts_ops_test_LP_MSPM0L2228_nortos_keil +hex
  BeforeMake: cmd.exe /C "$P../../../../../../tools/keil/syscfg.bat '$P' iqmath_rts_ops_test.syscfg"
  c flags: Optim=3 v6Lang=3 v6LangP=3 wLevel=4
  c define: __MSPM0L2228__
  c include: ../,../../../../../../source/third_party/CMSIS/Core/Include,../../../../../../source
  scatter file: ./mspm0l2228.sct
  link misc: ../../../../../../source/ti/driverlib/lib/keil/m0p/mspm0l122x_l222x/driverlib.a ../../../../../../source/ti/iqmath/lib/keil/m0p/rts/mspm0l122x_l222x/iqmath.a
  group Source
    ../: iqmath_rts_ops_test.c iqmath_rts_ops_test.syscfg ti_msp_dl_config.h ti_msp_dl_config.c
    ./: startup_mspm0l222x_uvision.s
