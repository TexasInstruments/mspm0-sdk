# Keil uVision project scratchpad_retain_on_vdd_loss_LP_MSPM0L2228_nortos_keil.uvprojx, settings and files
target scratchpad_retain_on_vdd_loss_LP_MSPM0L2228_nortos_keil (6160000::V6.16::ARMCLANG)
  device: MSPM0L2228 Texas Instruments
  output: scratchpad_retain_on_vdd_loss_LP_MSPM0L2228_nortos_keil
  BeforeMake: cmd.exe /C "$P../../../../../../tools/keil/syscfg.bat '$P' scratchpad_retain_on_vdd_loss.syscfg"
  c flags: Optim=3 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=4
  c define: __MSPM0L2228__
  c include: ../../../../../../source/third_party/CMSIS/Core/Include,../../../../../../source
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20200000 size 0x8000
  scatter file: .\mspm0l2228.sct
  group Source
    ../: scratchpad_retain_on_vdd_loss.c scratchpad_retain_on_vdd_loss.syscfg ti_msp_dl_config.c ti_msp_dl_config.h
    ./: startup_mspm0l222x_uvision.s
  group Driverlib
    ../../../../../../source/ti/driverlib/lib/keil/m0p/mspm0l122x_l222x/: driverlib.a
