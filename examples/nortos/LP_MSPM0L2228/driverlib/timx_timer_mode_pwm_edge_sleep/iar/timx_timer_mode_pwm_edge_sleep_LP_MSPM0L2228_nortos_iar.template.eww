<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
    <project>
        <path>$WS_DIR$/timx_timer_mode_pwm_edge_sleep_LP_MSPM0L2228_nortos_iar.ewp</path>
    </project>
    <batchBuild/>
</workspace>