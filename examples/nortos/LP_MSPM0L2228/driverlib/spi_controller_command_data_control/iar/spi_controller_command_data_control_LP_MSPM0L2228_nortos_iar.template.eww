<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
    <project>
        <path>$WS_DIR$/spi_controller_command_data_control_LP_MSPM0L2228_nortos_iar.ewp</path>
    </project>
    <batchBuild/>
</workspace>