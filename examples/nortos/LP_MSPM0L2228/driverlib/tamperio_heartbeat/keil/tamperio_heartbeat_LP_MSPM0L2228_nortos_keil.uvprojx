# Keil uVision project tamperio_heartbeat_LP_MSPM0L2228_nortos_keil.uvprojx, settings and files
target tamperio_heartbeat_LP_MSPM0L2228_nortos_keil (6160000::V6.16::ARMCLANG)
  device: MSPM0L2228 Texas Instruments
  output: tamperio_heartbeat_LP_MSPM0L2228_nortos_keil +hex
  BeforeMake: cmd.exe /C "$P../../../../../../tools/keil/syscfg.bat '$P' tamperio_heartbeat.syscfg"
  c flags: Optim=3 v6Lang=3 v6LangP=3 wLevel=4
  c define: __MSPM0L2228__
  c include: ../,../../../../../../source/third_party/CMSIS/Core/Include,../../../../../../source
  scatter file: ./mspm0l2228.sct
  link misc: ../../../../../../source/ti/driverlib/lib/keil/m0p/mspm0l122x_l222x/driverlib.a
  group Source
    ../: tamperio_heartbeat.c tamperio_heartbeat.syscfg ti_msp_dl_config.c ti_msp_dl_config.h
    ./: startup_mspm0l222x_uvision.s
