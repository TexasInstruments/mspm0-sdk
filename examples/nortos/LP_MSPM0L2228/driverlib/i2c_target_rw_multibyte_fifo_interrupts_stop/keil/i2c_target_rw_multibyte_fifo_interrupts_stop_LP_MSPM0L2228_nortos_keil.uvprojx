# Keil uVision project i2c_target_rw_multibyte_fifo_interrupts_stop_LP_MSPM0L2228_nortos_keil.uvprojx, settings and files
target i2c_target_rw_multibyte_fifo_interrupts_stop_LP_MSPM0L2228_nortos_keil (6160000::V6.16::ARMCLANG)
  device: MSPM0L2228 Texas Instruments
  output: i2c_target_rw_multibyte_fifo_interrupts_stop_LP_MSPM0L2228_nortos_keil
  BeforeMake: cmd.exe /C "$P../../../../../../tools/keil/syscfg.bat '$P' i2c_target_rw_multibyte_fifo_interrupts_stop.syscfg"
  c flags: Optim=3 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=4
  c define: __MSPM0L2228__
  c include: ../../../../../../source/third_party/CMSIS/Core/Include,../../../../../../source
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20200000 size 0x8000
  scatter file: .\mspm0l2228.sct
  group Source
    ../: i2c_target_rw_multibyte_fifo_interrupts_stop.c i2c_target_rw_multibyte_fifo_interrupts_stop.syscfg ti_msp_dl_config.h ti_msp_dl_config.c
    ./: startup_mspm0l222x_uvision.s
  group Driverlib
    ../../../../../../source/ti/driverlib/lib/keil/m0p/mspm0l122x_l222x/: driverlib.a
