# IAR project adc12_single_conversion_vref_external_LP_MSPM0L2228_nortos_iar.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCOptLevel: 2
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  group (top)
    ./: adc12_single_conversion_vref_external_LP_MSPM0L2228_nortos_iar.ipcf SysConfig_Generated_Files.ipcf
