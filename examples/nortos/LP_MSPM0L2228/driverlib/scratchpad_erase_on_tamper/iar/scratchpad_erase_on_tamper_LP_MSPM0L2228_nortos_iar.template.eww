<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
    <project>
        <path>$WS_DIR$/scratchpad_erase_on_tamper_LP_MSPM0L2228_nortos_iar.ewp</path>
    </project>
    <batchBuild/>
</workspace>