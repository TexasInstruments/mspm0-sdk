# Keil uVision project lin_responder_LP_MSPM0H3216_nortos_keil.uvprojx, settings and files
target lin_responder_LP_MSPM0H3216_nortos_keil (6160000::V6.16::ARMCLANG)
  device: MSPM0H3216 Texas Instruments
  output: lin_responder_LP_MSPM0H3216_nortos_keil +hex
  BeforeMake: cmd.exe /C "$P../../../../../../tools/keil/syscfg.bat '$P' lin_responder.syscfg"
  c flags: Optim=3 v6Lang=3 v6LangP=3 wLevel=4
  c define: __MSPM0H3216__
  c include: ../,../../../../../../source/third_party/CMSIS/Core/Include,../../../../../../source
  scatter file: ./mspm0h3216.sct
  link misc: ../../../../../../source/ti/driverlib/lib/keil/m0p/mspm0h321x/driverlib.a
  group Source
    ../: lin_responder.c lin_config.c lin_config.h lin_responder.syscfg ti_msp_dl_config.h ti_msp_dl_config.c
    ./: startup_mspm0h321x_uvision.s
