# Keil uVision project timx_timer_mode_capture_duty_and_period_LP_MSPM0L1306_nortos_keil.uvprojx, settings and files
target timx_timer_mode_capture_duty_and_period_LP_MSPM0L1306_nortos_keil (6160000::V6.16::ARMCLANG)
  device: MSPM0L1306 Texas Instruments
  pack: TexasInstruments.MSPM0L_DFP.0.1.23-eng0
  cpu: IRAM(0x20000000,0x00001000) IROM(0x00000000,0x00010000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: timx_timer_mode_capture_duty_and_period_LP_MSPM0L1306_nortos_keil +hex
  BeforeMake: cmd.exe /C "$P../../../../../../tools/keil/syscfg.bat '$P' timx_timer_mode_capture_duty_and_period.syscfg"
  c flags: Optim=3 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=4
  c define: __MSPM0L1306__
  c include: ../../../../../../source/third_party/CMSIS/Core/Include,../../../../../../source
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x1000
  scatter file: .\mspm0l1306.sct
  group Source
    ../: timx_timer_mode_capture_duty_and_period.c timx_timer_mode_capture_duty_and_period.syscfg ti_msp_dl_config.h ti_msp_dl_config.c
    ./: startup_mspm0l130x_uvision.s
  group Driverlib
    ../../../../../../source/ti/driverlib/lib/keil/m0p/mspm0l11xx_l13xx/: driverlib.a
