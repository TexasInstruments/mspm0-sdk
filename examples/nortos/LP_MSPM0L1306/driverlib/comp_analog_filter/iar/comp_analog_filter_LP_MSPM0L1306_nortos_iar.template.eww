<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
    <project>
        <path>$WS_DIR$/comp_analog_filter_LP_MSPM0L1306_nortos_iar.ewp</path>
    </project>
    <batchBuild/>
</workspace>