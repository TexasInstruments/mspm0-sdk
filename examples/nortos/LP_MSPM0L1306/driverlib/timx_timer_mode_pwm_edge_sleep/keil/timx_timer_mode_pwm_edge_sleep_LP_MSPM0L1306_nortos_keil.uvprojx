# Keil uVision project timx_timer_mode_pwm_edge_sleep_LP_MSPM0L1306_nortos_keil.uvprojx, settings and files
target timx_timer_mode_pwm_edge_sleep_LP_MSPM0L1306_nortos_keil (6160000::V6.16::ARMCLANG)
  device: MSPM0L1306 Texas Instruments
  output: timx_timer_mode_pwm_edge_sleep_LP_MSPM0L1306_nortos_keil +hex
  BeforeMake: cmd.exe /C "$P../../../../../../tools/keil/syscfg.bat '$P' timx_timer_mode_pwm_edge_sleep.syscfg"
  c flags: Optim=3 v6Lang=3 v6LangP=3 wLevel=4
  c define: __MSPM0L1306__
  c include: ../,../../../../../../source/third_party/CMSIS/Core/Include,../../../../../../source
  scatter file: ./mspm0l1306.sct
  link misc: ../../../../../../source/ti/driverlib/lib/keil/m0p/mspm0l11xx_l13xx/driverlib.a
  group Source
    ../: timx_timer_mode_pwm_edge_sleep.c timx_timer_mode_pwm_edge_sleep.syscfg ti_msp_dl_config.h ti_msp_dl_config.c
    ./: startup_mspm0l130x_uvision.s
