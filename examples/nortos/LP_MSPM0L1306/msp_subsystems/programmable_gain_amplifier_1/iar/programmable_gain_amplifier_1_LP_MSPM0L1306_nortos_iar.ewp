# IAR project programmable_gain_amplifier_1_LP_MSPM0L1306_nortos_iar.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCOptLevel: 2
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  group (top)
    ./: programmable_gain_amplifier_1_LP_MSPM0L1306_nortos_iar.ipcf SysConfig_Generated_Files.ipcf
