# IAR project two_opa_instrumentation_amplifier_LP_MSPM0L1306_nortos_iar.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCOptLevel: 2
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  group (top)
    ./: two_opa_instrumentation_amplifier_LP_MSPM0L1306_nortos_iar.ipcf SysConfig_Generated_Files.ipcf
