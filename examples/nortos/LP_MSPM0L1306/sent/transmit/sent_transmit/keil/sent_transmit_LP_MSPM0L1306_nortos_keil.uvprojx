# Keil uVision project sent_transmit_LP_MSPM0L1306_nortos_keil.uvprojx, settings and files
target sent_transmit_LP_MSPM0L1306_nortos_keil (6160000::V6.16::ARMCLANG)
  device: MSPM0L1306 Texas Instruments
  pack: TexasInstruments.MSPM0L_DFP.0.1.23-eng0
  cpu: IRAM(0x20000000,0x00001000) IROM(0x00000000,0x00010000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: sent_transmit_LP_MSPM0L1306_nortos_keil +hex
  BeforeMake: cmd.exe /C "$P../../../../../../../tools/keil/syscfg.bat '$P' sent_transmit.syscfg"
  c flags: Optim=3 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=4
  c define: __MSPM0L1306__
  c include: ../../../../../../../source/third_party/CMSIS/Core/Include,../../../../../../../source
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x1000
  scatter file: .\mspm0l1306.sct
  group Source
    ../SENT/: SENT.c SENT.h
    ../SENT/HAL/: HAL_GPIO.c HAL_GPIO.h hal_interrupts.c hal_interrupts.h hal_system.c hal_system.h hal_timer.c hal_timer.h hal.h
    ../: sent_transmit.c sent_transmit.syscfg ti_msp_dl_config.h ti_msp_dl_config.c
    ./: startup_mspm0l1306_uvision.s
  group Driverlib
    ../../../../../../../source/ti/driverlib/lib/keil/m0p/mspm0l11xx_l13xx/: driverlib.a
