# Keil uVision project eeprom_emulation_type_a_LP_MSPM0G3507_nortos_keil.uvprojx, settings and files
target eeprom_emulation_type_a_LP_MSPM0G3507_nortos_keil (6160000::V6.16::ARMCLANG)
  device: MSPM0G3507 Texas Instruments
  pack: TexasInstruments.MSPM0G_DFP.0.1.23-eng0
  cpu: IRAM(0x20000000,0x00008000) IRAM2(0x20200000,0x00008000) IROM(0x00000000,0x00020000) IROM2(0x00400000,0x00020000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: eeprom_emulation_type_a_LP_MSPM0G3507_nortos_keil +hex
  c flags: Optim=3 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=4
  c define: __MSPM0G3507__
  c include: ../../../../../../../source/third_party/CMSIS/Core/Include,../../../../../../../source
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT5: ROM 0x400000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  memory RVCT10: RAM 0x20200000 size 0x8000
  scatter file: .\mspm0g3507.sct
  group Source
    ../: main.c ti_msp_dl_config.h ti_msp_dl_config.c
    ../ti/eeprom/emulation_type_a/: eeprom_emulation_type_a.c eeprom_emulation_type_a.h
    ../ti/eeprom/emulation_type_b/: eeprom_emulation_type_b.c eeprom_emulation_type_b.h
    ./: startup_mspm0g350x_uvision.s
  group Driverlib
    ../../../../../../../source/ti/driverlib/lib/keil/m0p/mspm0g1x0x_g3x0x/: driverlib.a
  group Driverlib
    ../../../../../../../source/ti/driverlib/lib/keil/m0p/mspm0g1x0x_g3x0x/: driverlib.a
