# Keil uVision project i2c_controller_rw_repeated_start_fifo_interrupts_LP_MSPM0G3507_nortos_keil.uvprojx, settings and files
target i2c_controller_rw_repeated_start_fifo_interrupts_LP_MSPM0G3507_nortos_keil (6160000::V6.16::ARMCLANG)
  device: MSPM0G3507 Texas Instruments
  output: i2c_controller_rw_repeated_start_fifo_interrupts_LP_MSPM0G3507_nortos_keil +hex
  BeforeMake: cmd.exe /C "$P../../../../../../tools/keil/syscfg.bat '$P' i2c_controller_rw_repeated_start_fifo_interrupts.syscfg"
  c flags: Optim=3 v6Lang=3 v6LangP=3 wLevel=4
  c define: __MSPM0G3507__
  c include: ../,../../../../../../source/third_party/CMSIS/Core/Include,../../../../../../source
  scatter file: ./mspm0g3507.sct
  link misc: ../../../../../../source/ti/driverlib/lib/keil/m0p/mspm0g1x0x_g3x0x/driverlib.a
  group Source
    ../: i2c_controller_rw_repeated_start_fifo_interrupts.c i2c_controller_rw_repeated_start_fifo_interrupts.syscfg ti_msp_dl_config.h ti_msp_dl_config.c
    ./: startup_mspm0g350x_uvision.s
