# IAR project uart_extend_irda_receive_packet_LP_MSPM0G3507_nortos_iar.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCOptLevel: 2
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  group (top)
    ./: uart_extend_irda_receive_packet_LP_MSPM0G3507_nortos_iar.ipcf SysConfig_Generated_Files.ipcf
