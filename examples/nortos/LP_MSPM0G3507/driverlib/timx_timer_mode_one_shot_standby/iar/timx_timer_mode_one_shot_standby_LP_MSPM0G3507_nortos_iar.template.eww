<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
    <project>
        <path>$WS_DIR$/timx_timer_mode_one_shot_standby_LP_MSPM0G3507_nortos_iar.ewp</path>
    </project>
    <batchBuild/>
</workspace>