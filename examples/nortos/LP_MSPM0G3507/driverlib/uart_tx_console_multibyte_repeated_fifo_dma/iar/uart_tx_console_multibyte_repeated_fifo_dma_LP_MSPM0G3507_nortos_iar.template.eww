<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
    <project>
        <path>$WS_DIR$/uart_tx_console_multibyte_repeated_fifo_dma_LP_MSPM0G3507_nortos_iar.ewp</path>
    </project>
    <batchBuild/>
</workspace>