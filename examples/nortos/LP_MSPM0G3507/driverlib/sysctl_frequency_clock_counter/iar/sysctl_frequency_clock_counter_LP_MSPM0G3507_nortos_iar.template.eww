<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
    <project>
        <path>$WS_DIR$/sysctl_frequency_clock_counter_LP_MSPM0G3507_nortos_iar.ewp</path>
    </project>
    <batchBuild/>
</workspace>