<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
    <project>
        <path>$WS_DIR$/wwdt_interval_timer_lfxt_standby_LP_MSPM0G3507_nortos_iar.ewp</path>
    </project>
    <batchBuild/>
</workspace>