# Keil uVision project adc_simultaneous_sample_LP_MSPM0G3507_nortos_keil.uvprojx, settings and files
target adc_simultaneous_sample_LP_MSPM0G3507_nortos_keil (6160000::V6.16::ARMCLANG)
  device: MSPM0G3507 Texas Instruments
  output: adc_simultaneous_sample_LP_MSPM0G3507_nortos_keil +hex
  BeforeMake: cmd.exe /C "$P../../../../../../tools/keil/syscfg.bat '$P' adc_simultaneous_sample.syscfg"
  c flags: Optim=3 v6Lang=3 v6LangP=3 wLevel=4
  c define: __MSPM0G3507__
  c include: ../,../../../../../../source/third_party/CMSIS/Core/Include,../../../../../../source
  scatter file: ./mspm0g3507.sct
  link misc: ../../../../../../source/ti/driverlib/lib/keil/m0p/mspm0g1x0x_g3x0x/driverlib.a
  group Source
    ../: adc_simultaneous_sample.c adc_simultaneous_sample.syscfg ti_msp_dl_config.h ti_msp_dl_config.c
    ./: startup_mspm0g350x_uvision.s
