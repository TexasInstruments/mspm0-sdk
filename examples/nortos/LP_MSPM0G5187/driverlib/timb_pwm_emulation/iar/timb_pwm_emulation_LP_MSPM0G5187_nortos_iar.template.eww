<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
    <project>
        <path>$WS_DIR$/timb_pwm_emulation_LP_MSPM0G5187_nortos_iar.ewp</path>
    </project>
    <batchBuild/>
</workspace>