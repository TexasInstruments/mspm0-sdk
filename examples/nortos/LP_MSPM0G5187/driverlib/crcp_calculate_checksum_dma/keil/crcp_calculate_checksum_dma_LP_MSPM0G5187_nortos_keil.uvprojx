# Keil uVision project crcp_calculate_checksum_dma_LP_MSPM0G5187_nortos_keil.uvprojx, settings and files
target crcp_calculate_checksum_dma_LP_MSPM0G5187_nortos_keil (6160000::V6.16::ARMCLANG)
  device: MSPM0G5187 Texas Instruments
  output: crcp_calculate_checksum_dma_LP_MSPM0G5187_nortos_keil +hex
  BeforeMake: cmd.exe /C "$P../../../../../../tools/keil/syscfg.bat '$P' crcp_calculate_checksum_dma.syscfg"
  c flags: Optim=3 v6Lang=3 v6LangP=3 wLevel=4
  c define: __MSPM0G5187__
  c include: ../,../../../../../../source/third_party/CMSIS/Core/Include,../../../../../../source
  scatter file: ./mspm0g5187.sct
  link misc: ../../../../../../source/ti/driverlib/lib/keil/m0p/mspm0g518x/driverlib.a
  group Source
    ../: crcp_calculate_checksum_dma.c crcp_calculate_checksum_dma.syscfg ti_msp_dl_config.h ti_msp_dl_config.c
    ./: startup_mspm0g518x_uvision.s
