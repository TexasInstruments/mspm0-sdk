<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
    <project>
        <path>$WS_DIR$/frequency_counter_tone_detection_LP_MSPM0G5187_nortos_iar.ewp</path>
    </project>
    <batchBuild/>
</workspace>