# IAR project device_hid_generic_inout_LP_MSPM0G5187_nortos_iar.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  group (top)
    ./: device_hid_generic_inout_LP_MSPM0G5187_nortos_iar.ipcf SysConfig_Generated_Files.ipcf
