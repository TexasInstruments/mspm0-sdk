# IAR project host_msc_file_explorer_LP_MSPM0G5187_nortos_iar.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  group (top)
    ./: host_msc_file_explorer_LP_MSPM0G5187_nortos_iar.ipcf SysConfig_Generated_Files.ipcf
