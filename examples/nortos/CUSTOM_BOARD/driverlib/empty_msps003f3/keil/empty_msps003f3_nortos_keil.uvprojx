# Keil uVision project empty_msps003f3_nortos_keil.uvprojx, settings and files
target empty_msps003f3 (6160000::V6.16::ARMCLANG)
  device: MSPS003F3 Texas Instruments
  output: empty_msps003f3 +hex
  BeforeMake: cmd.exe /C "$P../../../../../../tools/keil/syscfg.bat '$P' empty_msps003f3.syscfg"
  c flags: Optim=3 v6Lang=3 v6LangP=3 wLevel=4
  c define: __MSPS003F3__
  c include: ../../../../../../source/third_party/CMSIS/Core/Include,../../../../../../source
  memory RVCT4: ROM 0x0 size 0x00002000
  memory RVCT9: RAM 0x20000000 size 0x00000400
  scatter file: .\msps003f3.sct
  group Source
    ../: empty_msps003f3.c empty_msps003f3.syscfg ti_msp_dl_config.h ti_msp_dl_config.c
    ./: startup_msps003f3_uvision.s
  group Driverlib
    ../../../../../../source/ti/driverlib/lib/keil/m0p/mspm0c110x/: driverlib.a
