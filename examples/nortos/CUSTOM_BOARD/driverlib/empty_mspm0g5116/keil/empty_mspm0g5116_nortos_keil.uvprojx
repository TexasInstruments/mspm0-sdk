# Keil uVision project empty_mspm0g5116_nortos_keil.uvprojx, settings and files
target empty_mspm0g5116 (6160000::V6.16::ARMCLANG)
  device: MSPM0G5116 Texas Instruments
  output: empty_mspm0g5116 +hex
  BeforeMake: cmd.exe /C "$P../../../../../../tools/keil/syscfg.bat '$P' empty_mspm0g5116.syscfg"
  c flags: Optim=3 v6Lang=3 v6LangP=3 wLevel=4
  c define: __MSPM0G5116__
  c include: ../../../../../../source/third_party/CMSIS/Core/Include,../../../../../../source
  memory RVCT4: ROM 0x0 size 0x00010000
  memory RVCT9: RAM 0x20000000 size 0x00008000
  scatter file: .\mspm0g5116.sct
  group Source
    ../: empty_mspm0g5116.c empty_mspm0g5116.syscfg ti_msp_dl_config.h ti_msp_dl_config.c
    ./: startup_mspm0g511x_uvision.s
  group Driverlib
    ../../../../../../source/ti/driverlib/lib/keil/m0p/mspm0g511x/: driverlib.a
