# Keil uVision project empty_mspm0g3519_nortos_keil.uvprojx, settings and files
target empty_mspm0g3519 (6160000::V6.16::ARMCLANG)
  device: MSPM0G3519 Texas Instruments
  output: empty_mspm0g3519 +hex
  BeforeMake: cmd.exe /C "$P../../../../../../tools/keil/syscfg.bat '$P' empty_mspm0g3519.syscfg"
  c flags: Optim=3 v6Lang=3 v6LangP=3 wLevel=4
  c define: __MSPM0G3519__
  c include: ../../../../../../source/third_party/CMSIS/Core/Include,../../../../../../source
  memory RVCT4: ROM 0x0 size 0x00080000
  memory RVCT9: RAM 0x20000000 size 0x00020000
  scatter file: .\mspm0g3519.sct
  group Source
    ../: empty_mspm0g3519.c empty_mspm0g3519.syscfg ti_msp_dl_config.h ti_msp_dl_config.c
    ./: startup_mspm0g351x_uvision.s
  group Driverlib
    ../../../../../../source/ti/driverlib/lib/keil/m0p/mspm0gx51x/: driverlib.a
