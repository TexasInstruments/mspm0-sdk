# Keil uVision project empty_mspm0g1507_nortos_keil.uvprojx, settings and files
target empty_mspm0g1507 (6160000::V6.16::ARMCLANG)
  device: MSPM0G1507 Texas Instruments
  output: empty_mspm0g1507 +hex
  BeforeMake: cmd.exe /C "$P../../../../../../tools/keil/syscfg.bat '$P' empty_mspm0g1507.syscfg"
  c flags: Optim=3 v6Lang=3 v6LangP=3 wLevel=4
  c define: __MSPM0G1507__
  c include: ../../../../../../source/third_party/CMSIS/Core/Include,../../../../../../source
  memory RVCT4: ROM 0x0 size 0x00020000
  memory RVCT9: RAM 0x20000000 size 0x00008000
  scatter file: .\mspm0g1507.sct
  group Source
    ../: empty_mspm0g1507.c empty_mspm0g1507.syscfg ti_msp_dl_config.h ti_msp_dl_config.c
    ./: startup_mspm0g1507_uvision.s
  group Driverlib
    ../../../../../../source/ti/driverlib/lib/keil/m0p/mspm0g1x0x_g3x0x/: driverlib.a
