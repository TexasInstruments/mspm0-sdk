# Keil uVision project empty_mspm0l1105_nortos_keil.uvprojx, settings and files
target empty_mspm0l1105 (6160000::V6.16::ARMCLANG)
  device: MSPM0L1105 Texas Instruments
  output: empty_mspm0l1105 +hex
  BeforeMake: cmd.exe /C "$P../../../../../../tools/keil/syscfg.bat '$P' empty_mspm0l1105.syscfg"
  c flags: Optim=3 v6Lang=3 v6LangP=3 wLevel=4
  c define: __MSPM0L1105__
  c include: ../../../../../../source/third_party/CMSIS/Core/Include,../../../../../../source
  memory RVCT4: ROM 0x0 size 0x00008000
  memory RVCT9: RAM 0x20000000 size 0x00001000
  scatter file: .\mspm0l1105.sct
  group Source
    ../: empty_mspm0l1105.c empty_mspm0l1105.syscfg ti_msp_dl_config.h ti_msp_dl_config.c
    ./: startup_mspm0l1105_uvision.s
  group Driverlib
    ../../../../../../source/ti/driverlib/lib/keil/m0p/mspm0l11xx_l13xx/: driverlib.a
