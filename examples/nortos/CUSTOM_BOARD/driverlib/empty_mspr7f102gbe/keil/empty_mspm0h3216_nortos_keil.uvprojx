# Keil uVision project empty_mspm0h3216_nortos_keil.uvprojx, settings and files
target empty_mspm0h3216 (6160000::V6.16::ARMCLANG)
  device: MSPM0H3216 Texas Instruments
  output: empty_mspm0h3216 +hex
  BeforeMake: cmd.exe /C "$P../../../../../../tools/keil/syscfg.bat '$P' empty_mspm0h3216.syscfg"
  c flags: Optim=3 v6Lang=3 v6LangP=3 wLevel=4
  c define: __MSPM0H3216__
  c include: ../../../../../../source/third_party/CMSIS/Core/Include,../../../../../../source
  memory RVCT4: ROM 0x0 size 0x00010000
  memory RVCT9: RAM 0x20000000 size 0x00002000
  scatter file: .\mspm0h3216.sct
  group Source
    ../: empty_mspm0h3216.c empty_mspm0h3216.syscfg ti_msp_dl_config.h ti_msp_dl_config.c
    ./: startup_mspm0h321x_uvision.s
  group Driverlib
    ../../../../../../source/ti/driverlib/lib/keil/m0p/mspm0h321x/: driverlib.a
