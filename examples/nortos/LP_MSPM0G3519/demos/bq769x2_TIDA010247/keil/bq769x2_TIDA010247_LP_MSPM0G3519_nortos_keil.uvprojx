# Keil uVision project bq769x2_TIDA010247_LP_MSPM0G3519_nortos_keil.uvprojx, settings and files
target bq769x2_TIDA010247_LP_MSPM0G3519_nortos_keil (6160000::V6.16::ARMCLANG)
  device: MSPM0G3519 Texas Instruments
  output: bq769x2_TIDA010247_LP_MSPM0G3519_nortos_keil +hex
  BeforeMake: cmd.exe /C "$P../../../../../../tools/keil/syscfg.bat '$P' bq769x2_TIDA010247.syscfg"
  c flags: Optim=3 v6Lang=3 v6LangP=3 wLevel=4
  c define: __MSPM0G3519__
  c include: ../,../../../../../../source/third_party/CMSIS/Core/Include,../../../../../../source
  scatter file: ./mspm0g3519.sct
  link misc: ../../../../../../source/ti/driverlib/lib/keil/m0p/mspm0gx51x/driverlib.a
  group Source
    ../BQ769x2_Configs/: BQ769x2_protocol.c BQ769x2_protocol.h
    ../Communications/: CAN_communication.c CAN_communication.h I2C_communication.c I2C_communication.h UART_communication.c UART_communication.h
    ../: App_task.c App_task.h main.c bq769x2_TIDA010247.syscfg ti_msp_dl_config.h ti_msp_dl_config.c
    ./: startup_mspm0g351x_uvision.s
