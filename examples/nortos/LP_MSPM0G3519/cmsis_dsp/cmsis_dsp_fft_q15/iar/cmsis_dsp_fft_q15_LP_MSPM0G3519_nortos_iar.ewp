# IAR project cmsis_dsp_fft_q15_LP_MSPM0G3519_nortos_iar.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCOptLevel: 2
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  group (top)
    ./: cmsis_dsp_fft_q15_LP_MSPM0G3519_nortos_iar.ipcf SysConfig_Generated_Files.ipcf
