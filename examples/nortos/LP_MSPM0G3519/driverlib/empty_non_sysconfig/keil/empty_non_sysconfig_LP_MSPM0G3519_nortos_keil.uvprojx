# Keil uVision project empty_non_sysconfig_LP_MSPM0G3519_nortos_keil.uvprojx, settings and files
target empty_non_sysconfig_LP_MSPM0G3519_nortos_keil (6160000::V6.16::ARMCLANG)
  device: MSPM0G3519 Texas Instruments
  output: empty_non_sysconfig_LP_MSPM0G3519_nortos_keil +hex
  c flags: Optim=3 v6Lang=3 v6LangP=3 wLevel=4
  c define: __MSPM0G3519__
  c include: ../,../../../../../../source/third_party/CMSIS/Core/Include,../../../../../../source
  scatter file: ./mspm0g3519.sct
  link misc: ../../../../../../source/ti/driverlib/lib/keil/m0p/mspm0gx51x/driverlib.a
  group Source
    ../: ti_msp_dl_config.c ti_msp_dl_config.h empty_non_sysconfig.c
    ./: startup_mspm0g351x_uvision.s
