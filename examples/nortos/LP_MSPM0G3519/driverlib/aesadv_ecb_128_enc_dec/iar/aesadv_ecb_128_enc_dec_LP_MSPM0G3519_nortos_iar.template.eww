<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
    <project>
        <path>$WS_DIR$/aesadv_ecb_128_enc_dec_LP_MSPM0G3519_nortos_iar.ewp</path>
    </project>
    <batchBuild/>
</workspace>