# Keil uVision project flashctl_blank_verify_LP_MSPM0G3519_nortos_keil.uvprojx, settings and files
target flashctl_blank_verify_LP_MSPM0G3519_nortos_keil (6160000::V6.16::ARMCLANG)
  device: MSPM0G3519 Texas Instruments
  output: flashctl_blank_verify_LP_MSPM0G3519_nortos_keil +hex
  BeforeMake: cmd.exe /C "$P../../../../../../tools/keil/syscfg.bat '$P' flashctl_blank_verify.syscfg"
  c flags: Optim=3 v6Lang=3 v6LangP=3 wLevel=4
  c define: __MSPM0G3519__
  c include: ../,../../../../../../source/third_party/CMSIS/Core/Include,../../../../../../source
  scatter file: ./mspm0g3519.sct
  link misc: ../../../../../../source/ti/driverlib/lib/keil/m0p/mspm0gx51x/driverlib.a
  group Source
    ../: flashctl_blank_verify.c flashctl_blank_verify.syscfg ti_msp_dl_config.h ti_msp_dl_config.c
    ./: startup_mspm0g351x_uvision.s
