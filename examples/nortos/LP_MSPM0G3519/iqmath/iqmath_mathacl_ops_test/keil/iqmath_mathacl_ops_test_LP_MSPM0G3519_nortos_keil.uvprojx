# Keil uVision project iqmath_mathacl_ops_test_LP_MSPM0G3519_nortos_keil.uvprojx, settings and files
target iqmath_mathacl_ops_test_LP_MSPM0G3519_nortos_keil (6160000::V6.16::ARMCLANG)
  device: MSPM0G3519 Texas Instruments
  output: iqmath_mathacl_ops_test_LP_MSPM0G3519_nortos_keil +hex
  BeforeMake: cmd.exe /C "$P../../../../../../tools/keil/syscfg.bat '$P' iqmath_mathacl_ops_test.syscfg"
  c flags: Optim=3 v6Lang=3 v6LangP=3 wLevel=4
  c define: __MSPM0G3519__
  c include: ../,../../../../../../source/third_party/CMSIS/Core/Include,../../../../../../source
  scatter file: ./mspm0g3519.sct
  link misc: ../../../../../../source/ti/driverlib/lib/keil/m0p/mspm0gx51x/driverlib.a ../../../../../../source/ti/iqmath/lib/keil/m0p/mathacl/mspm0gx51x/iqmath.a
  group Source
    ../: iqmath_mathacl_ops_test.c iqmath_mathacl_ops_test.syscfg ti_msp_dl_config.h ti_msp_dl_config.c
    ./: startup_mspm0g351x_uvision.s
