# Keil uVision project empty_non_sysconfig_LP_MSPM0L1117_nortos_keil.uvprojx, settings and files
target empty_non_sysconfig_LP_MSPM0L1117_nortos_keil (6160000::V6.16::ARMCLANG)
  device: MSPM0L1117 Texas Instruments
  output: empty_non_sysconfig_LP_MSPM0L1117_nortos_keil +hex
  c flags: Optim=3 v6Lang=3 v6LangP=3 wLevel=4
  c define: __MSPM0L1117__
  c include: ../../../../../../source/third_party/CMSIS/Core/Include,../../../../../../source
  scatter file: ./mspm0l1117.sct
  link misc: ../../../../../../source/ti/driverlib/lib/keil/m0p/mspm0l111x/driverlib.a ../../../../../../source/ti/driverlib/lib/keil/m0p/mspm0h321x/driverlib.a
  group Source
    ../: empty_non_sysconfig.c ti_msp_dl_config.c ti_msp_dl_config.h
    ./: startup_mspm0l111x_uvision.s
