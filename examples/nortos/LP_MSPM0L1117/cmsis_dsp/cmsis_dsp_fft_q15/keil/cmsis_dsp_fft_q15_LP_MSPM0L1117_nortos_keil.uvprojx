# Keil uVision project cmsis_dsp_fft_q15_LP_MSPM0L1117_nortos_keil.uvprojx, settings and files
target cmsis_dsp_fft_q15_LP_MSPM0L1117_nortos_keil (6160000::V6.16::ARMCLANG)
  device: MSPM0L1117 Texas Instruments
  output: cmsis_dsp_fft_q15_LP_MSPM0L1117_nortos_keil +hex
  BeforeMake: cmd.exe /C "$P../../../../../../tools/keil/syscfg.bat '$P' cmsis_dsp_fft_q15.syscfg"
  c flags: Optim=3 v6Lang=3 v6LangP=3 wLevel=4
  c define: __MSPM0L1117__,ARM_MATH_CM0
  c include: ../,../../../../../../source/third_party/CMSIS/Core/Include,../../../../../../source/third_party/CMSIS/DSP/Include,../../../../../../source
  scatter file: ./mspm0l1117.sct
  link misc: ../../../../../../source/third_party/CMSIS/DSP/lib/keil/m0p/arm_cortexM0l_math.a ../../../../../../source/ti/driverlib/lib/keil/m0p/mspm0l111x/driverlib.a
  group Source
    ../: cmsis_dsp_fft_q15.c cmsis_dsp_fft_q15.syscfg ti_msp_dl_config.h ti_msp_dl_config.c
    ./: startup_mspm0l111x_uvision.s
