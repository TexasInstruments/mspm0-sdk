# Keil uVision project uart_to_i2c_bridge_LP_MSPM0L1117_nortos_keil.uvprojx, settings and files
target uart_to_i2c_bridge_LP_MSPM0L1117_nortos_keil (6160000::V6.16::ARMCLANG)
  device: MSPM0L1117 Texas Instruments
  output: uart_to_i2c_bridge_LP_MSPM0L1117_nortos_keil +hex
  BeforeMake: cmd.exe /C "$P../../../../../../tools/keil/syscfg.bat '$P' uart_to_i2c_bridge.syscfg"
  c flags: Optim=3 v6Lang=3 v6LangP=3 wLevel=4
  c define: __MSPM0L1117__
  c include: ../,../../../../../../source/third_party/CMSIS/Core/Include,../../../../../../source
  scatter file: ./mspm0l1117.sct
  link misc: ../../../../../../source/ti/driverlib/lib/keil/m0p/mspm0l111x/driverlib.a
  group Source
    ../: uart_to_i2c_bridge.c uart_to_i2c_bridge.syscfg ti_msp_dl_config.h ti_msp_dl_config.c
    ./: startup_mspm0l111x_uvision.s
