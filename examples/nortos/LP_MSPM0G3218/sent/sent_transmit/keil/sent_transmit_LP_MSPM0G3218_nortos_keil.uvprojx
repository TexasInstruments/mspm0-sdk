# Keil uVision project sent_transmit_LP_MSPM0G3218_nortos_keil.uvprojx, settings and files
target sent_transmit_LP_MSPM0G3218_nortos_keil (6160000::V6.16::ARMCLANG)
  device: MSPM0G3218 Texas Instruments
  output: sent_transmit_LP_MSPM0G3218_nortos_keil +hex
  BeforeMake: cmd.exe /C "$P../../../../../../tools/keil/syscfg.bat '$P' sent_transmit.syscfg"
  c flags: Optim=3 v6Lang=3 v6LangP=3 wLevel=4
  c define: __MSPM0G3218__
  c include: ../,../../../../../../source/third_party/CMSIS/Core/Include,../../../../../../source
  scatter file: ./mspm0g3218.sct
  link misc: ../../../../../../source/ti/driverlib/lib/keil/m0p/mspm0gx218_gx207/driverlib.a
  group Source
    ../: sent_transmit.c sent_transmit.syscfg ti_msp_dl_config.h ti_msp_dl_config.c
    ../SENT/: SENT.c SENT.h
    ./: startup_mspm0g321x_uvision.s
