<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
    <project>
        <path>$WS_DIR$/rtc_b_offset_calibration_lfxt_LP_MSPM0G3218_nortos_iar.ewp</path>
    </project>
    <batchBuild/>
</workspace>