# IAR project timx_timer_mode_capture_duty_and_period_LP_MSPM0C1106_nortos_iar.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCOptLevel: 2
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  group (top)
    ./: timx_timer_mode_capture_duty_and_period_LP_MSPM0C1106_nortos_iar.ipcf SysConfig_Generated_Files.ipcf
