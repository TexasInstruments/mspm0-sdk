# Keil uVision project event_input_triggers_output_LP_MSPM0C1106_nortos_keil.uvprojx, settings and files
target event_input_triggers_output_LP_MSPM0C1106_nortos_keil (6160000::V6.16::ARMCLANG)
  device: MSPM0C1106 Texas Instruments
  output: event_input_triggers_output_LP_MSPM0C1106_nortos_keil +hex
  BeforeMake: cmd.exe /C "$P../../../../../../tools/keil/syscfg.bat '$P' event_input_triggers_output.syscfg"
  c flags: Optim=3 v6Lang=3 v6LangP=3 wLevel=4
  c define: __MSPM0C1106__
  c include: ../,../../../../../../source/third_party/CMSIS/Core/Include,../../../../../../source
  scatter file: ./mspm0c1106.sct
  link misc: ../../../../../../source/ti/driverlib/lib/keil/m0p/mspm0c1105_c1106/driverlib.a
  group Source
    ../: event_input_triggers_output.c event_input_triggers_output.syscfg ti_msp_dl_config.h ti_msp_dl_config.c
    ./: startup_mspm0c1105_c1106_uvision.s
