# Keil uVision project nvic_interrupt_disable_LP_MSPM0C1106_nortos_keil.uvprojx, settings and files
target nvic_interrupt_disable_LP_MSPM0C1106_nortos_keil (6160000::V6.16::ARMCLANG)
  device: MSPM0C1106 Texas Instruments
  output: nvic_interrupt_disable_LP_MSPM0C1106_nortos_keil +hex
  BeforeMake: cmd.exe /C "$P../../../../../../tools/keil/syscfg.bat '$P' nvic_interrupt_disable.syscfg"
  c flags: Optim=3 v6Lang=3 v6LangP=3 wLevel=4
  c define: __MSPM0C1106__
  c include: ../,../../../../../../source/third_party/CMSIS/Core/Include,../../../../../../source
  scatter file: ./mspm0c1106.sct
  link misc: ../../../../../../source/ti/driverlib/lib/keil/m0p/mspm0c1105_c1106/driverlib.a
  group Source
    ../: nvic_interrupt_disable.c nvic_interrupt_disable.syscfg ti_msp_dl_config.h ti_msp_dl_config.c
    ./: startup_mspm0c1105_c1106_uvision.s
