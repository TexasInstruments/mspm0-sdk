# Keil uVision project empty_non_sysconfig_LP_MSPM0C1106_nortos_keil.uvprojx, settings and files
target empty_non_sysconfig_LP_MSPM0C1106_nortos_keil (6160000::V6.16::ARMCLANG)
  device: MSPM0C1106 Texas Instruments
  output: empty_non_sysconfig_LP_MSPM0C1106_nortos_keil +hex
  c flags: Optim=3 v6Lang=3 v6LangP=3 wLevel=4
  c define: __MSPM0C1106__
  c include: ../,../../../../../../source/third_party/CMSIS/Core/Include,../../../../../../source
  scatter file: ./mspm0c1106.sct
  link misc: ../../../../../../source/ti/driverlib/lib/keil/m0p/mspm0c1105_c1106/driverlib.a
  group Source
    ../: ti_msp_dl_config.c ti_msp_dl_config.h empty_non_sysconfig.c
    ./: startup_mspm0c1105_c1106_uvision.s
