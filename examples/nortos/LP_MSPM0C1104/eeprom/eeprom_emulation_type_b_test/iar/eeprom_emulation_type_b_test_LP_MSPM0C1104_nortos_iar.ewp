# IAR project eeprom_emulation_type_b_test_LP_MSPM0C1104_nortos_iar.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCOptLevel: 2
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  group (top)
    ./: eeprom_emulation_type_b_test_LP_MSPM0C1104_nortos_iar.ipcf
