<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
    <project>
        <path>$WS_DIR$/eeprom_emulation_type_a_test_LP_MSPM0C1104_nortos_iar.ewp</path>
    </project>
    <batchBuild/>
</workspace>