# Keil uVision project spi_controller_internal_loopback_poll_LP_MSPM0C1104_nortos_keil.uvprojx, settings and files
target spi_controller_internal_loopback_poll_LP_MSPM0C1104_nortos_keil (6160000::V6.16::ARMCLANG)
  device: MSPM0C1104 Texas Instruments
  output: spi_controller_internal_loopback_poll_LP_MSPM0C1104_nortos_keil +hex
  BeforeMake: cmd.exe /C "$P../../../../../../tools/keil/syscfg.bat '$P' spi_controller_internal_loopback_poll.syscfg"
  c flags: Optim=3 v6Lang=3 v6LangP=3 wLevel=4
  c define: __MSPM0C1104__
  c include: ../../../../../../source/third_party/CMSIS/Core/Include,../../../../../../source
  memory RVCT4: ROM 0x0 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x400
  scatter file: .\mspm0c1104.sct
  group Source
    ../: spi_controller_internal_loopback_poll.c spi_controller_internal_loopback_poll.syscfg ti_msp_dl_config.h ti_msp_dl_config.c
    ./: startup_mspm0c1104_uvision.s
  group Driverlib
    ../../../../../../source/ti/driverlib/lib/keil/m0p/mspm0c110x/: driverlib.a
