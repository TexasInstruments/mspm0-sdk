# Keil uVision project sysctl_frequency_clock_counter_LP_MSPM0C1104_nortos_keil.uvprojx, settings and files
target sysctl_frequency_clock_counter_LP_MSPM0C1104_nortos_keil (6160000::V6.16::ARMCLANG)
  device: MSPM0C1104 Texas Instruments
  output: sysctl_frequency_clock_counter_LP_MSPM0C1104_nortos_keil +hex
  BeforeMake: cmd.exe /C "$P../../../../../../tools/keil/syscfg.bat '$P' sysctl_frequency_clock_counter.syscfg"
  c flags: Optim=3 v6Lang=3 v6LangP=3 wLevel=4
  c define: __MSPM0C1104__
  c include: ../,../../../../../../source/third_party/CMSIS/Core/Include,../../../../../../source
  scatter file: ./mspm0c1104.sct
  link misc: ../../../../../../source/ti/driverlib/lib/keil/m0p/mspm0c110x/driverlib.a
  group Source
    ../: sysctl_frequency_clock_counter.c sysctl_frequency_clock_counter.syscfg ti_msp_dl_config.h ti_msp_dl_config.c
    ./: startup_mspm0c110x_uvision.s
