<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
    <project>
        <path>$WS_DIR$/uart_extend_manchester_echo_LP_MSPM0C1104_nortos_iar.ewp</path>
    </project>
    <batchBuild/>
</workspace>