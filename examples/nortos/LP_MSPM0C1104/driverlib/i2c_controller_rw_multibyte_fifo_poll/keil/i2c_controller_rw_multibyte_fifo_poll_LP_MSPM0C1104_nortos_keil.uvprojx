# Keil uVision project i2c_controller_rw_multibyte_fifo_poll_LP_MSPM0C1104_nortos_keil.uvprojx, settings and files
target i2c_controller_rw_multibyte_fifo_poll_LP_MSPM0C1104_nortos_keil (6160000::V6.16::ARMCLANG)
  device: MSPM0C1104 Texas Instruments
  output: i2c_controller_rw_multibyte_fifo_poll_LP_MSPM0C1104_nortos_keil +hex
  BeforeMake: cmd.exe /C "$P../../../../../../tools/keil/syscfg.bat '$P' i2c_controller_rw_multibyte_fifo_poll.syscfg"
  c flags: Optim=3 v6Lang=3 v6LangP=3 wLevel=4
  c define: __MSPM0C1104__
  c include: ../,../../../../../../source/third_party/CMSIS/Core/Include,../../../../../../source
  scatter file: ./mspm0c1104.sct
  link misc: ../../../../../../source/ti/driverlib/lib/keil/m0p/mspm0c110x/driverlib.a
  group Source
    ../: i2c_controller_rw_multibyte_fifo_poll.c i2c_controller_rw_multibyte_fifo_poll.syscfg ti_msp_dl_config.h ti_msp_dl_config.c
    ./: startup_mspm0c110x_uvision.s
