# Keil uVision project empty_non_sysconfig_LP_MSPM0L2117_nortos_keil.uvprojx, settings and files
target empty_non_sysconfig_LP_MSPM0L2117_nortos_keil (6160000::V6.16::ARMCLANG)
  device: MSPM0L2117 Texas Instruments
  output: empty_non_sysconfig_LP_MSPM0L2117_nortos_keil +hex
  c flags: Optim=3 v6Lang=3 v6LangP=3 wLevel=4
  c define: __MSPM0L2117__
  c include: ../,../../../../../../source/third_party/CMSIS/Core/Include,../../../../../../source
  scatter file: ./mspm0l2117.sct
  link misc: ../../../../../../source/ti/driverlib/lib/keil/m0p/mspm0l211x_l112x/driverlib.a
  group Source
    ../: ti_msp_dl_config.c ti_msp_dl_config.h empty_non_sysconfig.c
    ./: startup_mspm0l211x_uvision.s
