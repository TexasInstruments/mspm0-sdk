# Keil uVision project lcd_write_memory_LP_MSPM0L2117_nortos_keil.uvprojx, settings and files
target lcd_write_memory_LP_MSPM0L2117_nortos_keil (6160000::V6.16::ARMCLANG)
  device: MSPM0L2117 Texas Instruments
  output: lcd_write_memory_LP_MSPM0L2117_nortos_keil +hex
  BeforeMake: cmd.exe /C "$P../../../../../../tools/keil/syscfg.bat '$P' lcd_write_memory.syscfg"
  c flags: Optim=3 v6Lang=3 v6LangP=3 wLevel=4
  c define: __MSPM0L2117__
  c include: ../,../../../../../../source/third_party/CMSIS/Core/Include,../../../../../../source
  scatter file: ./mspm0l2117.sct
  link misc: ../../../../../../source/ti/driverlib/lib/keil/m0p/mspm0l211x_l112x/driverlib.a
  group Source
    ../: lcd_write_memory.c lcd_write_memory.syscfg ti_msp_dl_config.c ti_msp_dl_config.h
    ./: startup_mspm0l211x_uvision.s
