# Keil uVision project empty_driverlib_src_LP_MSPM0L2117_nortos_keil.uvprojx, settings and files
target empty_driverlib_src_LP_MSPM0L2117_nortos_keil (6160000::V6.16::ARMCLANG)
  device: MSPM0L2117 Texas Instruments
  output: empty_driverlib_src_LP_MSPM0L2117_nortos_keil +hex
  BeforeMake: cmd.exe /C "$P../../../../../../tools/keil/syscfg.bat '$P' empty.syscfg"
  c flags: Optim=3 v6Lang=3 v6LangP=3 wLevel=4
  c define: __MSPM0L2117__
  c include: ../,../../../../../../source/third_party/CMSIS/Core/Include,../../../../../../source
  scatter file: ./mspm0l2117.sct
  link misc: ../../../../../../source/ti/driverlib/lib/keil/m0p/mspm0l211x_l112x/driverlib.a
  group Source
    ../: empty.c empty.syscfg ti_msp_dl_config.h ti_msp_dl_config.c
    ../ti/driverlib/: dl_adc12.h dl_aes.h dl_aesadv.h dl_common.h dl_comp.h dl_crc.h dl_crcp.h dl_dac12.h dl_dma.h dl_flashctl.h dl_gpamp.h dl_gpio.h dl_i2c.h dl_i2s.h dl_iwdt.h dl_keystorectl.h dl_lcd.h dl_lfss.h dl_mathacl.h dl_mcan.h dl_npu.h dl_opa.h dl_rtc.h dl_rtc_a.h dl_rtc_b.h dl_rtc_common.h dl_scratchpad.h dl_spgss.h dl_spi.h dl_tamperio.h dl_timer.h dl_timera.h dl_timerb.h dl_timerg.h dl_trng.h dl_uart.h dl_uart_extend.h dl_uart_main.h dl_unicomm.h dl_unicommi2cc.h dl_unicommi2ct.h dl_unicommspi.h dl_unicommuart.h dl_vref.h dl_wwdt.h driverlib.h dl_adc12.c dl_aes.c dl_aesadv.c dl_common.c dl_comp.c dl_crc.c dl_crcp.c dl_dac12.c dl_dma.c dl_flashctl.c dl_gpamp.c dl_gpio.c dl_i2c.c dl_i2s.c dl_iwdt.c dl_keystorectl.c dl_lcd.c dl_lfss.c dl_mathacl.c dl_mcan.c dl_npu.c dl_opa.c dl_rtc.c dl_rtc_a.c dl_rtc_b.c dl_rtc_common.c dl_scratchpad.c dl_spgss.c dl_spi.c dl_tamperio.c dl_timer.c dl_timera.c dl_timerb.c dl_timerg.c dl_trng.c dl_uart.c dl_unicomm.c dl_unicommi2cc.c dl_unicommi2ct.c dl_unicommspi.c dl_unicommuart.c dl_vref.c dl_wwdt.c
    ../ti/driverlib/m0p/: dl_core.h dl_factoryregion.h dl_interrupt.h dl_sysctl.h dl_systick.h dl_factoryregion.c dl_interrupt.c
    ../ti/driverlib/m0p/sysctl/: dl_sysctl_mspm0c1105_c1106.h dl_sysctl_mspm0c110x.h dl_sysctl_mspm0g1x0x_g3x0x.h dl_sysctl_mspm0g352x.h dl_sysctl_mspm0g511x.h dl_sysctl_mspm0g518x.h dl_sysctl_mspm0gx218_gx207.h dl_sysctl_mspm0gx51x.h dl_sysctl_mspm0h321x.h dl_sysctl_mspm0l111x.h dl_sysctl_mspm0l11xx_l13xx.h dl_sysctl_mspm0l122x_l222x.h dl_sysctl_mspm0l211x_l112x.h dl_sysctl_mspm0c1105_c1106.c dl_sysctl_mspm0c110x.c dl_sysctl_mspm0g1x0x_g3x0x.c dl_sysctl_mspm0g352x.c dl_sysctl_mspm0g511x.c dl_sysctl_mspm0g518x.c dl_sysctl_mspm0gx218_gx207.c dl_sysctl_mspm0gx51x.c dl_sysctl_mspm0h321x.c dl_sysctl_mspm0l111x.c dl_sysctl_mspm0l11xx_l13xx.c dl_sysctl_mspm0l122x_l222x.c dl_sysctl_mspm0l211x_l112x.c
    ./: startup_mspm0l211x_uvision.s
