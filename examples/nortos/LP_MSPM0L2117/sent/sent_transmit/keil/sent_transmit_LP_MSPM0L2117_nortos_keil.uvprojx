# Keil uVision project sent_transmit_LP_MSPM0L2117_nortos_keil.uvprojx, settings and files
target sent_transmit_LP_MSPM0L2117_nortos_keil (6160000::V6.16::ARMCLANG)
  device: MSPM0L2117 Texas Instruments
  output: sent_transmit_LP_MSPM0L2117_nortos_keil +hex
  BeforeMake: cmd.exe /C "$P../../../../../../tools/keil/syscfg.bat '$P' sent_transmit.syscfg"
  c flags: Optim=3 v6Lang=3 v6LangP=3 wLevel=4
  c define: __MSPM0L2117__
  c include: ../,../../../../../../source/third_party/CMSIS/Core/Include,../../../../../../source
  scatter file: ./mspm0l2117.sct
  link misc: ../../../../../../source/ti/driverlib/lib/keil/m0p/mspm0l211x_l112x/driverlib.a
  group Source
    ../: sent_transmit.c sent_transmit.syscfg ti_msp_dl_config.h ti_msp_dl_config.c
    ../SENT/: SENT.c SENT.h
    ./: startup_mspm0l211x_uvision.s
