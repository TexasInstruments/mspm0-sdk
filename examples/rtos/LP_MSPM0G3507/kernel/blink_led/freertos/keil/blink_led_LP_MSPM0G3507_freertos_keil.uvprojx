# Keil uVision project blink_led_LP_MSPM0G3507_freertos_keil.uvprojx, settings and files
target blink_led_LP_MSPM0G3507_freertos_keil (6160000::V6.16::ARMCLANG)
  device: MSPM0G3507 Texas Instruments
  pack: TexasInstruments.MSPM0G_DFP.0.1.23-eng0
  cpu: IRAM(0x20000000,0x00008000) IRAM2(0x20200000,0x00008000) IROM(0x00000000,0x00020000) IROM2(0x00400000,0x00020000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: blink_led_LP_MSPM0G3507_freertos_keil +hex
  BeforeMake: cmd.exe /C "$P../../../../../../../tools/keil/syscfg.bat '$P' blink_led.syscfg"
  c flags: Optim=3 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=4
  c define: __MSPM0G3507__
  c include: ../../../../../../../source/third_party/CMSIS/Core/Include,../../../../../../../kernel/freertos/Source/include,../../../../../../../source,../../../../../../../kernel/freertos/Source/portable/GCC/ARM_CM0,../../../../../../../kernel/freertos/builds/LP_MSPM0G3507/release
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT5: ROM 0x400000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  memory RVCT10: RAM 0x20200000 size 0x8000
  scatter file: .\mspm0g3507.sct
  group Source
    ../../: main.c main-blinky.c blink_led.syscfg ti_msp_dl_config.h ti_msp_dl_config.c
    ./: startup_mspm0g3507_uvision.s
  group Driverlib
    ../../../../../../../source/ti/driverlib/lib/keil/m0p/mspm0g1x0x_g3x0x/: driverlib.a
  group FreeRTOS Library
    ../../../../../../../kernel/freertos/builds/LP_MSPM0G3507/release/keil/Objects/: freertos_builds_LP_MSPM0G3507_release_keil.lib
