# IAR project blink_led_LP_MSPM0L1117_freertos_iar.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCOptLevel: 2
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  group (top)
    ./: blink_led_LP_MSPM0L1117_freertos_iar.ipcf SysConfig_Generated_Files.ipcf
