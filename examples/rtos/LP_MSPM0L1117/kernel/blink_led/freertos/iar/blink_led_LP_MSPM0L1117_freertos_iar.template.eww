<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
    <project>
        <path>$WS_DIR$/blink_led_LP_MSPM0L1117_freertos_iar.ewp</path>
    </project>
    <project>
        <path>$MSPM0_SDK_INSTALL_DIR$/kernel/freertos/builds/LP_MSPM0L1117/release/iar/freertos_builds_LP_MSPM0L1117_release.ewp</path>
    </project>
    <batchBuild/>
</workspace>