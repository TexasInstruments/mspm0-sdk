# Keil uVision project blink_led_LP_MSPM0L1117_freertos_keil.uvprojx, settings and files
target blink_led_LP_MSPM0L1117_freertos_keil (6160000::V6.16::ARMCLANG)
  device: MSPM0L1117 Texas Instruments
  output: blink_led_LP_MSPM0L1117_freertos_keil +hex
  BeforeMake: cmd.exe /C "$P../../../../../../../tools/keil/syscfg.bat '$P' blink_led.syscfg"
  c flags: Optim=3 v6Lang=3 v6LangP=3 wLevel=4
  c define: __MSPM0L1117__
  c include: ../,../../../../../../../source/third_party/CMSIS/Core/Include,../../../../../../../kernel/freertos/Source/include,../../../../../../../source,../../../../../../../kernel/freertos/Source/portable/GCC/ARM_CM0,../../../../../../../kernel/freertos/builds/LP_MSPM0L1117/release
  scatter file: ./mspm0l1117.sct
  link misc: ../../../../../../../source/ti/driverlib/lib/keil/m0p/mspm0l111x/driverlib.a ../../../../../../../kernel/freertos/builds/LP_MSPM0L1117/release/keil/Objects/freertos_builds_LP_MSPM0L1117_release_keil.lib
  group Source
    ../../: main.c main-blinky.c blink_led.syscfg ti_msp_dl_config.h ti_msp_dl_config.c
    ./: startup_mspm0l111x_uvision.s
