# Keil uVision project freertos_builds_LP_MSPM0L1117_release_keil.uvprojx, settings and files
target freertos_builds_LP_MSPM0L1117_release_keil (6180000::V6.18::ARMCLANG)
  device: MSPM0L1117 Texas Instruments
  output: freertos_builds_LP_MSPM0L1117_release_keil +hex (library)
  c flags: Optim=3 OneElfS=1 v6Lang=3 v6LangP=3
  c define: __MSPM0L1117__
  c include: ../../../../../../source;../../../../../../source/third_party/CMSIS/Core/Include;../../../../../../kernel/freertos/Source/include;..\..\..\..\..\..\kernel\freertos\Source\portable\GCC\ARM_CM0;../
  group Header files
    ../: FreeRTOSConfig.h
  group Source files
    ../../../../../../kernel/freertos/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../../../../../../kernel/freertos/Source/portable/MemMang/: heap_4.c
    ../../../../../../kernel/freertos/Source/portable/GCC/ARM_CM0/: port.c portasm.c
    ../../../../../../kernel/freertos/dpl/: AppHooks_freertos.c ClockP_freertos.c DebugP_freertos.c MutexP_freertos.c SemaphoreP_freertos.c SystemP_freertos.c StaticAllocs_freertos.c TaskP_freertos.c HwiPMSPM0_freertos.c
    ../../../../../../source/ti/devices/msp/m0p/startup_system_files/keil/: startup_mspm0l111x_uvision.s
