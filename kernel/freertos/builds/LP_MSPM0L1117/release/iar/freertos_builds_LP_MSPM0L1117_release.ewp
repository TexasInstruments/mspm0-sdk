# IAR project freertos_builds_LP_MSPM0L1117_release.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MSPM0L1117 TexasInstruments MSPM0L1117
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.IExtraOptions: -D__MSPM0L1117__; -Dewarm; -I$MSPM0_SDK_INSTALL_DIR$/kernel/freertos/Source/include; -I$MSPM0_SDK_INSTALL_DIR$/kernel/freertos/Source/portable/IAR/ARM_CM0; -I$MSPM0_SDK_INSTALL_DIR$/source/ti/posix/iar; -I$MSPM0_SDK_INSTALL_DIR$/kernel/freertos/startup; -I$MSPM0_SDK_INSTALL_DIR$/source; -I$MSPM0_SDK_INSTALL_DIR$/source/third_party/CMSIS/Core/Include; -I..; --debug; --silent; -e; --aeabi; --thumb; --diag_suppress=Pa050
  ICCARM.CCOptLevel: 2
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  AARM.AUserIncludes: $MSPM0_SDK_INSTALL_DIR$/kernel/freertos/Source/include; ..
  OBJCOPY.OOCOutputFile: freertos_builds_LP_MSPM0L1117_release.srec
  ILINK.IlinkOutputFile: freertos_builds_LP_MSPM0L1117_release.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group FreeRTOS kernel project/Header files
    ../: FreeRTOSConfig.h
  group FreeRTOS kernel project/Source files
    $MSPM0_SDK_INSTALL_DIR$/kernel/freertos/dpl/: AppHooks_freertos.c ClockP_freertos.c DebugP_freertos.c HwiPMSPM0_freertos.c TaskP_freertos.c StaticAllocs_freertos.c MutexP_freertos.c SemaphoreP_freertos.c SystemP_freertos.c
    $MSPM0_SDK_INSTALL_DIR$/source/ti/posix/freertos/: clock.c memory.c mqueue.c Mtx.c pthread.c pthread_barrier.c pthread_cond.c pthread_mutex.c pthread_rwlock.c sched.c semaphore.c sleep.c timer.c
    $MSPM0_SDK_INSTALL_DIR$/kernel/freertos/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    $MSPM0_SDK_INSTALL_DIR$/kernel/freertos/Source/portable/MemMang/: heap_4.c
    $MSPM0_SDK_INSTALL_DIR$/kernel/freertos/Source/portable/IAR/ARM_CM0/: port.c portasm.s
    $MSPM0_SDK_INSTALL_DIR$/source/ti/devices/msp/m0p/startup_system_files/iar/: startup_mspm0l111x_iar.c
