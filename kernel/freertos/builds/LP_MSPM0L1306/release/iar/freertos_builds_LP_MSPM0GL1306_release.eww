<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$/freertos_builds_LP_MSPM0L1306_release.ewp</path>
  </project>
  <batchBuild/>
</workspace>
